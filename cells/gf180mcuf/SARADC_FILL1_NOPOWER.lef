VERSION 5.7 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SARADC_FILL1_NOPOWER
  CLASS BLOCK ;
  FOREIGN SARADC_FILL1_NOPOWER ;
  ORIGIN 0.000 0.000 ;
  SIZE 0.560 BY 7.840 ;
  SYMMETRY X Y R90 ;
END SARADC_FILL1_NOPOWER

END LIBRARY
